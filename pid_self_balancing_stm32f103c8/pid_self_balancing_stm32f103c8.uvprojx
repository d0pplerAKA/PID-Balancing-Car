# Keil uVision project pid_self_balancing_stm32f103c8.uvprojx, settings and files
target Target 1 (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pid_self_balancing_stm32f103c8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=0,REMOVE_LOGGING,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c include: .\CMSIS;.\FWLIB\inc;.\FWLIB\src;.\User;.\User\header;.\User\motion_driver_dmp;.\User\motion_driver_dmp\driver\eMPL;.\User\motion_driver_dmp\driver\include;.\User\motion_driver_dmp\driver\stm32L;.\User\motion_driver_dmp\eMPL-hal;.\User\motion_driver_dmp\mllite;.\User\motion_driver_dmp\mpl;.\User\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./CMSIS/STARTUP/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group Header
    ./User/header/: Delay.c EncoderMotor.c Head.c Led.c MPU_Rotation.c MPU6050.c OLED_Font.c OLED_SH1106.c PID.c Timer.c UART.c I2c.c MPU_DMP_Rotation.c
  group User
    ./User/: main.c stm32f10x_it.c
  group motion_driver_dmp
    ./User/motion_driver_dmp/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./User/motion_driver_dmp/driver/stm32L/: log_stm32.c
    ./User/motion_driver_dmp/eMPL-hal/: eMPL_outputs.c
    ./User/motion_driver_dmp/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./User/motion_driver_dmp/mpl/: libmpllib.lib
